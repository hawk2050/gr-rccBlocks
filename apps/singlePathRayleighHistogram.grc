<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fdTs</value></param>
<param><key>value</key><value>fd*(1.0/chan_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chan_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1+1j</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>chan_rate</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>k</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>20</value></param>
</block>
<block>
<key>rccBlocks_rayleighChan_cc</key>
<param><key>id</key><value>rccBlocks_rayleighChan_cc_0</value></param>
<param><key>seed</key><value>randint(-10e3, 0)</value></param>
<param><key>fD</key><value>fdTs</value></param>
<param><key>pwr</key><value>1.0</value></param>
<param><key>flag_indep</key><value>False</value></param>
<param><key>mode</key><value>fadeMode</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fd</value></param>
<param><key>label</key><value>Doppler Rate, Hz</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>fadeMode</value></param>
<param><key>label</key><value>Fading Enabled</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>25000</value></param>
<param><key>srate</key><value>chan_rate</value></param>
<param><key>ymin</key><value>-50</value></param>
<param><key>ymax</key><value>20</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1500000</value></param>
<param><key>bins</key><value>100</value></param>
<param><key>xmin</key><value>0</value></param>
<param><key>xmax</key><value>4</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>172.16.54.28</value></param>
<param><key>port</key><value>1234</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rccBlocks_rayleighChan_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rccBlocks_rayleighChan_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
