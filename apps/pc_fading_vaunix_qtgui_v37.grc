<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pc_fading_vaunix_qtgui</value></param>
<param><key>title</key><value>Static RF or Single Path Rayleigh Faded RF</value></param>
<param><key>author</key><value>Richard Clarke</value></param>
<param><key>description</key><value>Provides either static RF or single path Rayleigh faded RF at specified doppler spread</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fdTs</value></param>
<param><key>value</key><value>fd*(1.0/usrpRate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>centreFreq</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baseband_multiplier</value></param>
<param><key>value</key><value>0.25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrpRate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>B:AB</value></param>
<param><key>samp_rate</key><value>usrpRate</value></param>
<param><key>center_freq0</key><value>centreFreq</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>fd</value></param>
<param><key>label</key><value>Doppler Rate, Hz</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>fadeMode</value></param>
<param><key>label</key><value>Fading Enabled</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>value</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>1234</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>usrpRate</value></param>
</block>
<block>
<key>rccBlocks_VNXLabBrick</key>
<param><key>id</key><value>rccBlocks_VNXLabBrick_0</value></param>
<param><key>atten</key><value>atten</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>1+1j</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>baseband_multiplier</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>atten</value></param>
<param><key>label</key><value>RF Attenuator Setting, dB</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>63</value></param>
<param><key>step</key><value>2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>rccBlocks_rayleighChan_cc</key>
<param><key>id</key><value>rccBlocks_rayleighChan_cc_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>seed</key><value>randint(-10e3, 0)</value></param>
<param><key>fD</key><value>200e-6</value></param>
<param><key>pwr</key><value>1.0</value></param>
<param><key>flag_indep</key><value>False</value></param>
<param><key>mode</key><value>True</value></param>
</block>
<block>
<key>rccBlocks_rayleighChan_cc</key>
<param><key>id</key><value>rccBlocks_rayleighChan_cc_0</value></param>
<param><key>seed</key><value>randint(-10e3, 0)</value></param>
<param><key>fD</key><value>fdTs</value></param>
<param><key>pwr</key><value>1.0</value></param>
<param><key>flag_indep</key><value>False</value></param>
<param><key>mode</key><value>bool(fadeMode)</value></param>
</block>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>rccBlocks_VNXLabBrick_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>rccBlocks_rayleighChan_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rccBlocks_rayleighChan_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>rccBlocks_rayleighChan_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rccBlocks_rayleighChan_cc_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
